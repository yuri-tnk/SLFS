# IAR project test_slfs.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1766 NXP LPC1766
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: TNKERNEL_PORT_CORTEXM3
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: test_slfs.hex
  ILINK.IlinkOutputFile: test1.out
  ILINK.IlinkIcfFile: LPC1766_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: cstartup_LPC176X.s startup_hardware_init_iar.s
  group cpu
    ../../../../../cpu/LPC17XX/: lpc17xx_core.c
  group fs_common
    ../../../../../fs_common/: df_create_init.c df_disk_access.c df_flash.c
  group slfs
    ../../../../../slfs/: slfs_api.c slfs_api_ex.c slfs_create_init.c slfs_log.c
  group test_slfs
    ../../../test_slfs/: main.c shell.c slfs_rand.c slfs_test_utilities.c slfs_tst_dump.c tn_sprintf.c tn_user.c unix_str_func.c utils.c
  group TNKernel
    ../../../../../TNKernel/: tn.c tn_dqueue.c tn_event.c tn_mem.c tn_mutex.c tn_sem.c tn_tasks.c tn_utils.c
    ../../../../../TNKernel/CortexM3/: tn_port_cm3.c tn_port_cm3_iar.s
