# Keil uVision project test_slfs.uvproj, settings and files
target test_slfs (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: test_slfs +hex
  c flags: Optim=2 oTime=1
  c define: TNKERNEL_PORT_CORTEXM3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\test_slfs.sct
  group test_slfs
    ./: startup_hardware_init.s startup_LPC17xx.s
    ../../../test_slfs/: main.c slfs_rand.c slfs_test_utilities.c slfs_tst_dump.c tn_sprintf.c tn_user.c utils.c shell.c
  group TNKernel
    ../../../../../TNKernel/: tn_utils.c tn.c tn_dqueue.c tn_event.c tn_mem.c tn_mutex.c tn_sem.c tn_tasks.c
    ../../../../../TNKernel/CortexM3/: tn_port_cm3.c tn_port_cm3_armcc.s
  group fs_common
    ../../../../../fs_common/: df_flash.c df_create_init.c df_disk_access.c
  group slfs
    ../../../../../slfs/: slfs_log.c slfs_api.c slfs_api_ex.c slfs_create_init.c
  group cpu
    ../../../../../cpu/LPC17XX/: lpc17xx_core.c
